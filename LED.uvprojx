# Keil uVision project LED.uvprojx, settings and files
target LED (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\LIB\inc;..\CORE;..\USER;..\Hardware\LED;..\Hardware\PWM;..\Hardware\SYSTEM;..\Hardware\UART;..\Hardware\EXTI;..\Hardware\ADC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: system_stm32f10x.c stm32f10x_it.c main.c
  group Hardware
    ../Hardware/LED/: led.c
    ../Hardware/PWM/: PWM.c
    ../Hardware/SYSTEM/: Delay.c
    ../Hardware/UART/: uart.c
    ../Hardware/EXTI/: exti.c
    ../Hardware/ADC/: adc.c
  group LIB
    ../LIB/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_adc.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
